inherit setuptools
require python-sentry-sdk.inc
