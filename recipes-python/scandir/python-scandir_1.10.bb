inherit setuptools
require python-scandir.inc

SRCREV = "982e6ba60e7165ef965567eacd7138149c9ce292"

