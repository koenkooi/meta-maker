inherit pypi setuptools
require python-filetype.inc
