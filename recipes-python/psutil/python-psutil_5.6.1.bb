inherit pypi setuptools
require python-psutil.inc

SRC_URI[md5sum] = "765a4179f02c149794a6e99d890dfa4b"
SRC_URI[sha256sum] = "fa0a570e0a30b9dd618bffbece590ae15726b47f9f1eaf7518dfb35f4d7dcd21"

