require python-netifaces.inc

inherit setuptools

SRC_URI[md5sum] = "de92cc322b4f56047c073f802ad77860"
SRC_URI[sha256sum] = "2dee9ffdd16292878336a58d04a20f0ffe95555465fee7c9bd23b3490ef2abf3"
